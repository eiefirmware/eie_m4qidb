<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Flash Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\libraries\CMSIS\include\stm32f4xx.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\CMSIS\include\system_stm32f4xx.h</name>
      </file>
    </group>
    <group>
      <name>source</name>
      <file>
        <name>$PROJ_DIR$\..\libraries\CMSIS\source\Templates\iar\startup_stm32f4xx.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\CMSIS\source\Templates\system_stm32f4xx.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>EIE</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\include\boardtest.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\include\configuration.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\include\debug_serial.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\include\m4qidb-pcb-01.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\include\misc_io.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\include\typedefs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\include\utilities.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\source\boardtest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\source\debug_serial.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\source\m4qidb-pcb-01.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\source\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\source\misc_io.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\eie_st32m4_qi\source\utilities.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>FreeRTOS</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\FreeRTOS.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\FreeRTOSConfig.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\list.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\mpu_wrappers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\portable.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\portmacro.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\projdefs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\queue.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\semphr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\StackMacros.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\task.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\include\timers.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\rtos\source\flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\source\heap_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\source\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\source\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\source\portasm.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\source\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\source\tasks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\rtos\source\timers.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>STM32F4xx_StdPeriph_Driver</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\arm_comm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4x7_eth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4x7_eth_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_dac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_dbgmcu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_dcmi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_rcc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_rng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_syscfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_tim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\include\stm32f4xx_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\source\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\source\stm32f4xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\source\stm32f4xx_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\source\stm32f4xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\source\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\source\stm32f4xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\source\stm32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\source\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\source\stm32f4xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\source\stm32f4xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\STM32F4xx_StdPeriph_Driver\source\stm32f4xx_usart.c</name>
      </file>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\..\stm32f4xx_flash.icf</name>
  </file>
</project>


