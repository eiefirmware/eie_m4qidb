# IAR project eie_st32m4_qi.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\rtos\include\; ..\libraries\STM32F4xx_StdPeriph_Driver\include\; ..\libraries\eie_st32m4_qi\include\; ..\libraries\CMSIS\include\; ..\libraries\FreeRTOS-Plus-UDP\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\; ..\rtos\include\
  OBJCOPY.OOCOutputFile: eie_st32m4_qi.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: stm32f4xx_flash.icf
  group CMSIS/include
    ../libraries/CMSIS/include/: stm32f4xx.h system_stm32f4xx.h
  group CMSIS/source
    ../libraries/CMSIS/source/Templates/iar/: startup_stm32f4xx.s
    ../libraries/CMSIS/source/Templates/: system_stm32f4xx.c
  group EIE/Include
    ../libraries/eie_st32m4_qi/include/: boardtest.h configuration.h debug_serial.h m4qidb-pcb-01.h misc_io.h typedefs.h utilities.h
  group EIE/Source
    ../libraries/eie_st32m4_qi/source/: boardtest.c debug_serial.c m4qidb-pcb-01.c main.c misc_io.c utilities.c
  group FreeRTOS/Include
    ../rtos/include/: flash.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/Source
    ../rtos/source/: flash.c heap_4.c list.c port.c portasm.s queue.c tasks.c timers.c
  group STM32F4xx_StdPeriph_Driver/Include
    ../libraries/STM32F4xx_StdPeriph_Driver/include/: arm_comm.h misc.h stm32f4x7_eth.h stm32f4x7_eth_conf.h stm32f4xx_adc.h stm32f4xx_conf.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_it.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group STM32F4xx_StdPeriph_Driver/Source
    ../libraries/STM32F4xx_StdPeriph_Driver/source/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_it.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
